# Keil uVision project 2dx_studio_8c.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab7_ToF
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: C:\Keil_v5\ARM\ARMCLANG\include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: PLL.c SysTick.c vl53l1_platform_2dx4.c VL53L1X_api.c onboardLEDs.c uart.c measure.c measure.h spin_motor.h spin_motor.c main.c I2C_init.h I2C_init.c onboard_button.h onboard_button.c variables.h bus_speed_demo.h bus_speed_demo.c
software components: CMSIS:CORE 5.6.0, Device:Startup 3.2.3
